* EESchema Netlist Version 1.0 (Spice format) creation date: 12/8/2006-03:14:18

C721  40 39 0.1uF
C722  41 42 0.1uF
C724  43 0 0.1uF
C723  38 44 0.1uF
U721  39 44 40 41 42 43 35 33 29 31 32 30 34 36 0 38 MAX3232
C711  0 38 0.1uF
C701  0 38 0.1uF
R711  49 50 120
R701  51 52 120
U711  47 0 38 45 50 49 SN65HVD232Q
U701  48 0 38 46 52 51 SN65HVD232Q
U421  53 0 38 LM3940
C442  58 0 0.1uF
C441  54 0 0.1uF
L441  54 58 22uH
C432  38 0 0.1uF
C431  0 53 0.1uF
U431  53 55 59 0 0 1 2 38 SN74LVC2T45DCTR
R412  53 59 10K
R402  53 55 10K
R411  38 3 10K
R401  38 4 10K
C413  58 0 47uF
C414  58 0 47uF
C403  58 0 47uF
C404  58 0 47uF
C406  63 0 100uF
C416  60 0 100uF
C422  38 0 33uF
C421  53 0 0.47uF
U402  4 63 0 MC34064P
U412  3 60 0 MC34064P
D402  63 53 1N5400
D412  60 53 1N5400
C417  60 0 100uF
L411  61 60 22uH
D411  0 61 B340LA-13
C411  56 61 0.01uF
C412  58 0 0.1uF
C415  58 0 47uF
U411  61 58 56 0 62 53 59 LM2676
C407  63 0 100uF
L401  64 63 22uH
D401  0 64 B340LA-13
C401  57 64 0.01uF
C402  58 0 0.1uF
C405  58 0 47uF
U401  64 58 57 0 65 53 55 LM2676
R270  76 74 RPDN
R271  77 74 RPDN
R272  78 74 RPDN
R273  75 74 RPDN
R274  79 74 RPDN
R275  80 74 RPDN
R276  81 74 RPDN
R277  82 74 RPDN
R254  38 79 RPUP
R255  38 80 RPUP
R257  38 82 RPUP
R256  38 81 RPUP
C344  74 79 0.1uF
C347  74 82 0.1uF
C346  74 81 0.1uF
C345  74 80 0.1uF
D247  74 82 3.3V
D246  74 81 3.3V
D245  74 80 3.3V
D244  74 79 3.3V
R264  69 79 RIN
R265  68 80 RIN
R267  66 82 RIN
R266  67 81 RIN
D243  83 75 3.3V
D242  74 78 3.3V
D241  74 77 3.3V
D240  74 76 3.3V
C340  74 76 0.1uF
C343  74 75 0.1uF
R250  38 76 RPUP
R260  73 76 RIN
R261  72 77 RIN
C342  74 78 0.1uF
R251  38 77 RPUP
R253  38 75 RPUP
R252  38 78 RPUP
C341  74 77 0.1uF
R263  70 75 RIN
R262  71 78 RIN
R340  93 74 RPDN
R341  94 74 RPDN
R342  95 74 RPDN
R343  92 74 RPDN
R344  96 74 RPDN
R345  97 74 RPDN
R346  98 74 RPDN
R347  99 74 RPDN
R234  38 96 RPUP
R235  38 97 RPUP
R237  38 99 RPUP
R236  38 98 RPUP
C334  74 96 0.1uF
C337  74 99 0.1uF
C336  74 98 0.1uF
C335  74 97 0.1uF
D337  74 99 3.3V
D336  74 98 3.3V
D335  74 97 3.3V
D334  74 96 3.3V
R334  87 96 RIN
R335  86 97 RIN
R337  84 99 RIN
R336  85 98 RIN
D333  100 92 3.3V
D332  74 95 3.3V
D331  74 94 3.3V
D330  74 93 3.3V
C330  74 93 0.1uF
C333  74 92 0.1uF
R320  38 93 RPUP
R330  91 93 RIN
R331  90 94 RIN
C332  74 95 0.1uF
R321  38 94 RPUP
R323  38 92 RPUP
R322  38 95 RPUP
C331  74 94 0.1uF
R333  88 92 RIN
R332  89 95 RIN
Q204  17 16 0 BU914Z
Q203  18 15 0 BU914Z
Q202  19 14 0 BU914Z
Q201  20 13 0 BU914Z
R204  101 17 480
R203  101 18 480
R202  101 19 480
R201  101 20 480
P1  38 111 EFIDBG
U3  28 27 26 25 24 23 22 21 0 0 120 121 122 123 124 125 126 127 ULN2803A
R20  38 110 470
R19  38 109 470
BAR1  119 118 117 116 115 114 113 112 109 110 170 171 120 121 122 123 124 125 126 127 DOT-BAR
R32  38 17 10K
R31  38 18 10K
R30  38 19 10K
R29  38 20 10K
R28  21 0 10K
R27  22 0 10K
R26  23 0 10K
R25  24 0 10K
R24  25 0 10K
R23  26 0 10K
R22  27 0 10K
R21  28 0 10K
R18  111 112 470
R17  111 113 470
R16  111 114 470
R15  111 115 470
R14  111 116 470
R13  111 117 470
R12  111 118 470
R11  111 119 470
X1  182 181 8 MHz
R5  167 166 470
D1  38 167 LED
K2  0 175 38 MODB
K1  0 172 38 MODA
R4  172 173 10K
R3  175 174 10K
U2  20 19 18 17 169 169 168 168 0 0 170 170 171 171 176 177 178 179 ULN2803A
R2  38 180 10K
R1  182 181 10M
C2  0 182 22pF
C1  0 181 22pF
U1  129 128 217 216 215 214 219 218 232 231 230 229 0 187 209 208 207 206 205 204 203 202 201 21 22 23 24 228 227 226 225 25 26 27 28 17 18 19 20 102 102 103 104 224 223 222 221 180 0 188 213 212 185 0 0 192 184 183 0 181 182 0 190 166 168 169 4 3 174 173 200 199 198 197 196 195 194 0 242 241 240 2 1 220 0 189 165 164 163 162 161 160 159 158 157 156 155 154 153 152 151 150 149 148 147 146 145 193 0 53 0 144 143 142 141 140 139 138 137 136 135 134 191 0 0 186 105 106 107 108 233 234 235 236 237 238 239 211 210 133 132 131 130 MAC7101
Q508  264 5 266 2N6044
Q507  261 6 267 2N6044
Q506  258 7 268 2N6044
Q505  256 8 269 2N6044
Q504  253 9 270 2N6044
Q503  251 10 271 2N6044
Q502  246 11 272 2N6044
Q501  245 12 273 2N6044
C521  38 0 0.1uF
C522  38 0 0.1uF
C523  38 0 0.1uF
C524  38 0 0.1uF
C525  38 0 0.1uF
C526  38 0 0.1uF
C527  38 0 0.1uF
C528  38 0 0.1uF
C518  0 265 CPEAK
R518  265 38 RPEAK
R517  260 38 RPEAK
C517  0 260 CPEAK
C508  264 263 0.1uF
C507  261 262 0.1uF
C516  0 274 CPEAK
R516  274 38 RPEAK
C506  258 259 0.1uF
C515  0 257 CPEAK
R515  257 38 RPEAK
C505  256 255 0.1uF
C514  0 252 CPEAK
R514  252 38 RPEAK
C504  253 254 0.1uF
C513  0 249 CPEAK
R513  249 38 RPEAK
C503  251 250 0.1uF
R512  248 38 RPEAK
C512  0 248 CPEAK
C502  246 247 0.1uF
C511  0 243 CPEAK
R511  243 38 RPEAK
U508  0 21 264 263 266 0 38 265 LM1949
C501  245 244 0.1uF
U507  0 22 261 262 267 0 38 260 LM1949
U506  0 23 258 259 268 0 38 274 LM1949
U505  0 24 256 255 269 0 38 257 LM1949
U504  0 25 253 254 270 0 38 252 LM1949
U503  0 26 251 250 271 0 38 249 LM1949
U502  0 27 246 247 272 0 38 248 LM1949
U501  0 28 245 244 273 0 38 243 LM1949
R508  266 0 0.1
R507  267 0 0.1
R506  268 0 0.1
R505  269 0 0.1
R504  270 0 0.1
R503  271 0 0.1
R502  272 0 0.1
R501  273 0 0.1
D506  0 7 33V/5W
D505  0 8 33V/5W
D504  0 9 33V/5W
D503  0 10 33V/5W
D502  0 11 33V/5W
D501  0 12 33V/5W
D507  0 6 33V/5W
D508  0 5 33V/5W
J1  13 14 12 11 10 9 54 0 0 316 315 314 313 312 311 298 297 296 295 294 293 292 291 290 289 288 287 286 285 283 284 282 281 280 279 278 277 276 275 310 309 308 307 306 305 304 303 302 301 300 299 0 0 54 5 6 7 8 15 16 581-01-60-005

.end
